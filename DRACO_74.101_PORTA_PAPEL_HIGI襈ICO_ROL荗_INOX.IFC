Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_74.101_PORTA_PAPEL_HIGIÊNICO_ROLÃO_INOX.IFC
Time: 2022-12-28T14:04:10
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_74.101_1_TUBO_INTERNO_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_74.101_2_FUNDO_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_74.101_3_CORPO_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_74.101_4_TAMPA_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: PAPEL_ROLÃO_DIÂM.250mm_Default
In: Default Storey
Material: Papel canelado
